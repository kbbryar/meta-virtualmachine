KBRANCH_vm-libvirtarm64  = "v5.8/standard/qemuarm64"

KMACHINE_vm-libvirtarm64 ?= "common-pc-64"

SRCREV_machine_vm-libvirtarm64 ?= "5981001bf03f0d0c1cf641a2287ab6368baf628a"

COMPATIBLE_MACHINE_vm-libvirtarm64 = "vm-libvirtarm64"

LINUX_VERSION_vm-libvirtarm64 = "5.8.13"
